## configs/ali_defconfig
```kconfig
CONFIG_CROSS_COMPILE="aarch64-linux-gnu-"
CONFIG_QCOM_MSM8953=y
CONFIG_MOTOROLA_ALI=y
```
